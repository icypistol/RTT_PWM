# Keil uVision project stm32F103ze_pwm.uvprojx, settings and files
target pwm (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32F103ze_pwm +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F103xE
  c include: .;.\include;.\bsp\stm32\warshipv3\applications;.\bsp\stm32\warshipv3\board\CubeMX_Config\Inc;.\bsp\stm32\warshipv3\board;.\bsp\stm32\libraries\HAL_Drivers;.\bsp\stm32\libraries\HAL_Drivers\config;.\libcpu\arm\common;.\libcpu\arm\cortex-m3;.\components\drivers\include;.\components\finsh;.\components\libc\compilers\common;.\bsp\stm32\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;.\bsp\stm32\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;.\bsp\stm32\libraries\STM32F1xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\stm32F103ze_pwm.sct
  group kernel
    ./src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group application
    ./bsp/stm32/warshipv3/applications/: main.c Process.c Tasks.c
  group drivers
    ./bsp/stm32/warshipv3/board/: board.c
    ./bsp/stm32/warshipv3/board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    ./bsp/stm32/libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_pwm.c drv_common.c
    ./bsp/stm32/libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group cpu
    ./libcpu/arm/common/: backtrace.c div0.c showmem.c
    ./libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ./components/drivers/hwtimer/: hwtimer.c
    ./components/drivers/misc/: pin.c rt_drv_pwm.c
    ./components/drivers/serial/: serial.c
    ./components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ./components/finsh/: shell.c cmd.c msh.c
  group libc
    ./components/libc/compilers/common/: time.c
  group stm32_HAL
    ./bsp/stm32/libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ./bsp/stm32/libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_sram.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
